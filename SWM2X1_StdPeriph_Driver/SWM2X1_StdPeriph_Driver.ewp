# IAR project SWM2X1_StdPeriph_Driver.ewp, settings and files
configuration SWM201 (ARM, debug)
  General.OGChipSelectEditMenu: SWM201x6 Synwit SWM201x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM201
  ICCARM.CCIncludePath2: .\CSL\CMSIS\CoreSupport; .\CSL\CMSIS\DeviceSupport; .\CSL\SWM2X1_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM201
  OBJCOPY.OOCOutputFile: SWM2X1_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: SWM2X1_StdPeriph_Driver.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SWM211 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SWM211x8 Synwit SWM211x8
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM211
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM211
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM2X1_StdPeriph_Driver/: SWM2X1_port.c SWM2X1_gpio.c SWM2X1_exti.c SWM2X1_timr.c SWM2X1_uart.c SWM2X1_adc.c SWM2X1_i2c.c SWM2X1_pwm.c SWM2X1_rtc.c SWM2X1_wdt.c SWM2X1_sleep.c SWM2X1_div.c SWM2X1_cordic.c SWM2X1_spi.c SWM2X1_qei.c SWM2X1_dma.c SWM2X1_can.c SWM201_flash.c SWM211_flash.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM201.c system_SWM211.c
    ./CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM201.s startup_SWM211.s
