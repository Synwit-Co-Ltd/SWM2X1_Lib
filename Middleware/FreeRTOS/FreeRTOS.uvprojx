# Keil uVision project FreeRTOS.uvprojx, settings and files
target SWM201 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM201x6 Synwit
  pack: Synwit.SWM32_DFP.2.0.3
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: FreeRTOS
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: CHIP_SWM201
  c include: ..\..\SWM2X1_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM2X1_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM2X1_StdPeriph_Driver\CSL\SWM2X1_StdPeriph_Driver;.\APP;.\APP\FreeRTOS\include;.\APP\FreeRTOS\portable\RVDS\ARM_CM0
  asm define: CHIP_SWM201
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS\port
    ./APP/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ./APP/FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ../../SWM2X1_StdPeriph_Driver/CSL/SWM2X1_StdPeriph_Driver/: SWM2X1_adc.c SWM2X1_exti.c SWM2X1_gpio.c SWM2X1_i2c.c SWM2X1_pwm.c SWM2X1_timr.c SWM2X1_uart.c SWM2X1_wdt.c SWM2X1_port.c SWM2X1_rtc.c SWM201_flash.c SWM211_flash.c
  group CSL\CMSIS
    ../../SWM2X1_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM201.c system_SWM211.c
    ../../SWM2X1_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM201.s startup_SWM211.s
target SWM211 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM211x8 Synwit
  pack: Synwit.SWM32_DFP.2.0.3
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: FreeRTOS
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: CHIP_SWM211
  c include: as above
  asm define: CHIP_SWM211
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
