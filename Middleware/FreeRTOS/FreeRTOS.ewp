# IAR project FreeRTOS.ewp, settings and files
configuration SWM201 (ARM, debug)
  General.OGChipSelectEditMenu: SWM201x6 Synwit SWM201x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM201
  ICCARM.CCIncludePath2: ..\..\SWM2X1_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM2X1_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM2X1_StdPeriph_Driver\CSL\SWM2X1_StdPeriph_Driver; .\APP; .\APP\FreeRTOS\include; .\APP\FreeRTOS\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM201
  AARM.AUserIncludes: .\APP
  OBJCOPY.OOCOutputFile: FreeRTOS.srec
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SWM211 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SWM211x8 Synwit SWM211x8
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM211
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR; CHIP_SWM211
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS\port
    ./APP/FreeRTOS/portable/IAR/ARM_CM0/: portasm.s port.c
    ./APP/FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ../../SWM2X1_StdPeriph_Driver/CSL/SWM2X1_StdPeriph_Driver/: SWM2X1_adc.c SWM2X1_exti.c SWM2X1_gpio.c SWM2X1_i2c.c SWM2X1_pwm.c SWM2X1_timr.c SWM2X1_uart.c SWM2X1_wdt.c SWM2X1_port.c SWM2X1_rtc.c SWM201_flash.c SWM211_flash.c
  group CSL\CMSIS
    ../../SWM2X1_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM201.c system_SWM211.c
    ../../SWM2X1_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM201.s startup_SWM211.s
